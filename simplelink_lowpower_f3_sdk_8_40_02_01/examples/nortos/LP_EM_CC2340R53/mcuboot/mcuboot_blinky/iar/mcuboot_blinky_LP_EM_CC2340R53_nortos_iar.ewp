# IAR project mcuboot_blinky_LP_EM_CC2340R53_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  group (top)
    ./: mcuboot_blinky_LP_EM_CC2340R53_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
